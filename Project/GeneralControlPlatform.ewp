# IAR project GeneralControlPlatform.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030F4 ST STM32F030F4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ../SysCore/Core; ../SysCore/Drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f0xx.bin
  ILINK.IlinkOutputFile: GeneralControlPlatform.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f030x4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  group ALG
    ../ALG/: crc16.c crc8.c
  group Application
    ../Application/: GC_HardwareDef.h GC_HwCfg.c GC_HwCfg.h GC_IOCtrl.c GC_IOCtrl.h GC_KeyProc.c GC_KeyProc.h GC_LedCtrl.c GC_LedCtrl.h GC_MainProc.c GC_MainProc.h GC_SysCtrl.c GC_SysCtrl.h
  group DataType
    ../DataType/: DataType.h
  group Main
    ../Main/: Main.c
  group PeriDrivers/Eeprom
    ../PeriDrivers/Eeprom/: at24cxx.c at24cxx.h
  group PeriDrivers/NixieTube
    ../PeriDrivers/NixieTube/: NixieTube.c NixieTube.h TM1617.c TM1617.h
  group SysCore/Core
    ../SysCore/Core/: chip.h core_cm0.h core_cmFunc.h core_cmInstr.h data_types.h ring_buffer.c ring_buffer.h stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
  group SysCore/Drivers
    ../SysCore/Drivers/: stm32f0xx_adc.c stm32f0xx_adc.h stm32f0xx_can.c stm32f0xx_can.h stm32f0xx_cec.c stm32f0xx_cec.h stm32f0xx_comp.c stm32f0xx_comp.h stm32f0xx_crc.c stm32f0xx_crc.h stm32f0xx_crs.c stm32f0xx_crs.h stm32f0xx_dac.c stm32f0xx_dac.h stm32f0xx_dbgmcu.c stm32f0xx_dbgmcu.h stm32f0xx_dma.c stm32f0xx_dma.h stm32f0xx_exti.c stm32f0xx_exti.h stm32f0xx_flash.c stm32f0xx_flash.h stm32f0xx_gpio.c stm32f0xx_gpio.h stm32f0xx_i2c.c stm32f0xx_i2c.h stm32f0xx_iwdg.c stm32f0xx_iwdg.h stm32f0xx_misc.c stm32f0xx_misc.h stm32f0xx_pwr.c stm32f0xx_pwr.h stm32f0xx_rcc.c stm32f0xx_rcc.h stm32f0xx_rtc.c stm32f0xx_rtc.h stm32f0xx_spi.c stm32f0xx_spi.h stm32f0xx_syscfg.c stm32f0xx_syscfg.h stm32f0xx_tim.c stm32f0xx_tim.h stm32f0xx_usart.c stm32f0xx_usart.h stm32f0xx_wwdg.c stm32f0xx_wwdg.h
  group SysCore/Startup
    ../SysCore/Startup/: startup_stm32f0xx.s
  group SysInit
    ../SysInit/: SYS_Init.c SYS_Init.h
  group SysPeripheral
    ../SysPeripheral/: Demo.c Demo.h
  group SysPeripheral/GPIO
    ../SysPeripheral/GPIO/: GPIO_Man.c GPIO_Man.h
  group SysPeripheral/HAL
    ../SysPeripheral/HAL/: HAL_Exti.c HAL_Exti.h HAL_Gpio.c HAL_Gpio.h HAL_IRQHandler.c HAL_IRQHandler.h HAL_SysCtrl.c HAL_SysCtrl.h HAL_SysInit.c HAL_SysInit.h HAL_SysTick.c HAL_SysTick.h HAL_TimeDelay.c HAL_TimeDelay.h HAL_Uart.c HAL_Uart.h HAL_Watchdog.c HAL_Watchdog.h ReadMe.txt
  group SysPeripheral/I2C
    ../SysPeripheral/I2C/: I2C_BaseOps.c I2C_DataStructDef.h I2C_DeviceAPI.c I2C_DeviceOps.c I2C_Interface.h
  group SysPeripheral/IRQ
    ../SysPeripheral/IRQ/: IRQ_Man.c IRQ_Man.h
  group SysPeripheral/KEY
    ../SysPeripheral/KEY/: KEY.c KEY.h
  group SysPeripheral/SysTick
    ../SysPeripheral/SysTick/: SysTick.c SysTick.h SysTimer.c SysTimer.h
  group SysPeripheral/UART
    ../SysPeripheral/UART/: UART.c UART.h UartDataStructDef.h UartInterface.c UartInterface.h ucom.c ucom.h
  group Version
    ../Version/: VER_DataStructDef.h Version.h
